# IAR project uCOS-II.ewp, settings and files
configuration FLASH (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103x8 ST STM32F103x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; _DLIB_FILE_DESCRIPTOR
  ICCARM.CCIncludePath2: ..\System\Processor\IAR; ..\System\Processor\STM32F10x\inc; ..\System\uCOS-II\uC-CPU; ..\System\uCOS-II\uC-LIB; ..\System\uCOS-II\uC-Kernel\Ports; ..\System\uCOS-II\uC-Kernel\Source; ..\DeviceDrive\Share; ..\DeviceDrive\Bsp; ..\DeviceDrive\Key; ..\DeviceDrive\Led; ..\DeviceDrive\Uart; ..\DeviceDrive\Power; ..\DeviceDrive\Oled; ..\DeviceDrive\Buzzer; ..\DeviceDrive\Paw; ..\DeviceDrive\i2c_ee; ..\Application\Main\inc; ..\Application\Monitor; ..\Application\ShutDown; ..\Application\StartingUp; ..\Application\PowerApp; ..\Application\DataSamp; ..\Application\Timer; ..\Application\Alarm; ..\Application\KeyApp; ..\Application\Display; ..\Application\Calibration; ..\Application\Serial\SerialApp; ..\Application\Serial\SerialServe
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.AUserIncludes: E:\03-project\01-682\01-code\68B_V0.0.01_150826_Beta\DeviceDrive\Paw
  OBJCOPY.OOCOutputFile: (1.0.0.20140409_Bate)Stm32F10x-6000CVentilatorPowerBoardContorller.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\System\Processor\IAR\STM32F103ZE_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/Alarm
    ../Application/Alarm/: Alarm.c Alarm.h
  group Application/Calibration
    ../Application/Calibration/: Calibration.c Calibration.h
  group Application/DataSamp
    ../Application/DataSamp/: DataSamp.c DataSamp.h
  group Application/Display
    ../Application/Display/: Display.c Display.h
  group Application/KeyApp
    ../Application/KeyApp/: KeyApp.c KeyApp.h
  group Application/Main/inc
    ../Application/Main/inc/: includes.h os_cfg.h stm32f10x_conf.h
  group Application/Main/src
    ../Application/Main/src/: Main.c
  group Application/Monitor
    ../Application/Monitor/: Monitor.c Monitor.h
  group Application/ShutDown
    ../Application/ShutDown/: ShutDown.c ShutDown.h
  group Application/StartingUp
    ../Application/StartingUp/: StartingUp.c StartingUp.h
  group Application/Timer
    ../Application/Timer/: TIME_Timer.c TIME_Timer.h
  group DeviceDrive/Bsp
    ../DeviceDrive/Bsp/: App_vect_v5.c Bsp.c Bsp.h Bsp_int.c Bsp_periph.c
  group DeviceDrive/Buzzer
    ../DeviceDrive/Buzzer/: Buzzer.c Buzzer.h
  group DeviceDrive/i2c_ee
    ../DeviceDrive/i2c_ee/: i2c_ee.c i2c_ee.h
  group DeviceDrive/Key
    ../DeviceDrive/Key/: Key.c Key.h
  group DeviceDrive/Led
    ../DeviceDrive/Led/: Led.c Led.h
  group DeviceDrive/Oled
    ../DeviceDrive/Oled/: k096.c k096.h Oled.c Oled.h
  group DeviceDrive/Paw
    ../DeviceDrive/Paw/: Paw.c Paw.h
  group DeviceDrive/Power
    ../DeviceDrive/Power/: Power.c Power.h
  group DeviceDrive/Share
    ../DeviceDrive/Share/: Share.h
  group DeviceDrive/Uart
    ../DeviceDrive/Uart/: Uart.c Uart.h
  group System/Processor/IAR
    ../System/Processor/IAR/: STM32F103ZE_FLASH.icf
  group System/Processor/STM32F10x/inc
    ../System/Processor/STM32F10x/inc/: cortexm3_macro.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_lib.h stm32f10x_map.h stm32f10x_nvic.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_systick.h stm32f10x_tim.h stm32f10x_type.h stm32f10x_usart.h stm32f10x_wwdg.h
  group System/Processor/STM32F10x/src
    ../System/Processor/STM32F10x/src/: stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_systick.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group System/uC/OS-II/uC-Kernel/Ports
    ../System/uCOS-II/uC-Kernel/Ports/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
  group System/uC/OS-II/uC-Kernel/Source
    ../System/uCOS-II/uC-Kernel/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.h
  group System/uC/OS-II/uC/CPU
    ../System/uCOS-II/uC-CPU/: cpu.h cpu_a.asm cpu_c.c cpu_def.h
  group System/uC/OS-II/uC/LIB
    ../System/uCOS-II/uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_mem.c lib_mem.h lib_str.c lib_str.h
